# Keil uVision project EthernetYTeclado.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: EthernetYTeclado
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT6: RAM 0x20010000 size 0x1000
  memory RVCT9: RAM 0x20011000 size 0x3f000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source
    ./: main.c HTTP_Server_CGI.c HTTP_Upload.c Web.c main.h stdout_display.c hx711.c hx711.h
  group Web files
    ./Web/: dir.cgi format.cgi home.png index.htm keil.gif llblue.jpg logo.gif pabb.gif pg_footer.inc pg_header.inc upload.cgi
software components: CMSIS:CORE 5.1.2, CMSIS:RTOS2:Keil RTX5 5.4.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:File 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0, File System:CORE 6.10.1, File System:Drive:Memory Card 6.10.1, Network:CORE 7.9.0, Network:Interface:ETH 7.9.0, Network:Service:Web Server 7.9.0, Network:Socket:TCP 7.9.0, Network:Socket:UDP 7.9.0, USB:CORE 6.12.8, USB:Host 6.12.8, USB:Host:HID 6.12.8, Board Support:Drivers:SDRAM 1.1.1, Board Support:Graphic LCD 1.1.1, Board Support:LED 1.1.1, CMSIS Driver:Ethernet MAC 1.6.0, CMSIS Driver:Ethernet PHY:LAN8742A 1.2.0, CMSIS Driver:MCI 1.6.0, CMSIS Driver:USB Host:Full-speed 1.9.0, CMSIS Driver:USB Host:High-speed 1.12.0, Device:STM32Cube Framework:Classic 1.2.6, Device:STM32Cube HAL:Common 1.2.6, Device:STM32Cube HAL:Cortex 1.2.6, Device:STM32Cube HAL:DMA 1.2.6, Device:STM32Cube HAL:GPIO 1.2.6, Device:STM32Cube HAL:LTDC 1.2.6, Device:STM32Cube HAL:PWR 1.2.6, Device:STM32Cube HAL:RCC 1.2.6, Device:STM32Cube HAL:SDRAM 1.2.6, Device:STM32Cube HAL:SRAM 1.2.6, Device:Startup 1.2.2
